# Keil uVision project drumbox_405.uvproj, settings and files
target drumbox_405 Configuration (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: drumbox_405 Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx
  c misc: --C99
  c include: ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Inc; ..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\Drivers\CMSIS\Include; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\Inc; ..\..\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Drivers\CMSIS\Include; ..\..\Inc; ; ..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc; ; ..\..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc; ; ..\..\Drivers\CMSIS\Include
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../../Src/: adc.c dma.c gpio.c i2c.c i2s.c main.c rng.c spi.c stm32f4xx_it.c tim.c usart.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c waveplayer.c sinewave.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_ll_usb.c
  group Middlewares/USB_Device_Library
    ../../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f405xx.s
